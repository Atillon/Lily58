File: rgb_array.kicad_sch (KiCad schematic)
At the start: 59 parts

Commit message: renamed rgb matrix -> rgb array
Parts:
- renumbered C11 to C?, R11 to R?
